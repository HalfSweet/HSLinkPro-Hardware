# Repository HalfSweet/HSLinkPro-Hardware

File README.md:

# HSLinkPro

HSLink Pro是一款基于HPM5301系列MCU的调试器。最高SWD/JTAG通信速率可达80M，并且拥有一路USB转串口，并带有DTR与RTS的输出，方便某些串口下载的MCU应用。

HSLink Pro软件参考<https://github.com/cherry-embedded/CherryDAP>。

## KiCAD 版本

使用8.0以上版本的KiCAD打开。

## KiCad design HSLinkPro.kicad_pcb

Parts:
C21, C22: 15p; C_0402_1005Metric
C23, C57: 0.1u; C_0402_1005Metric
D1: WS2812B; LED_WS2812_0807
J3: Header 1.27 4P; PinHeader_1x04_P1.27mm_Vertical; not fitted
R1, R17, R18: 10k; R_0402_1005Metric
R9, R10, R11, R12, R21: 100k; R_0402_1005Metric
R22, R23: 22R; R_0402_1005Metric
SW1: 1TS028A-1900-0600-CT; SW-SMD_4P-L2.8-W1.9-P1.20-LS3.0_1TS028A
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
Y1: 24M; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C57.1, D1.1 (VDD), J3.1, R1.1, SW1.2; also elsewhere on the board
/ADC_TVCC: R11.2, R12.1, U1.26 (PB09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI2.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)
/ADC_VREF: R9.2, R10.1, U1.27 (PB08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI2.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)
/BOOT0: D1.4 (DIN), R17.1, U1.8 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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)
/BOOT1: R18.1, SW1.1, U1.7 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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)
/ISP_RX: J3.3, U1.11 (PA01/TMR1.CAPT0/URT0.RXD/TRGM0.P01/ACMP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)
/ISP_TX: J3.2, U1.12 (PA00/TMR1.COMP0/URT0.TXD/TRGM0.P00)
/NRST: C23.1, R1.2, U1.13 (~RESETN)
/P_EN: R21.1, U1.19 (PY00/URT0.TXD/USB0.ID/PMIC_PY00/PURT.TX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); also elsewhere on the board
/SPI_CS: U1.25 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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), U1.42 (PA26/SPI1.CS0/XPI0.CA_D3/TRGM0.P02)
/SRST: U1.20 (PB15/TMR0.COMP3/URT3.TXD/SPI2.DAT3/TRGM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); also elsewhere on the board
/SWCLK/TCK: U1.24 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/ADC0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), U1.41 (PA27/SPI1.SCLK/XPI0.CA_SCLK/TRGM0.P03); also elsewhere on the board
/SWDIO_DIR: U1.38 (PA30/SPI1.DAT2/XPI0.CA_D1/TRGM0.P06/USB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); also elsewhere on the board
/SWDIO/TMS: R22.1, R23.1; also elsewhere on the board
/TDI: U1.22 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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); also elsewhere on the board
/TDO: U1.23 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/TRGM0.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); also elsewhere on the board
/TRANS_PWM: U1.4 (PA10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI3.C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); also elsewhere on the board
/TRST: U1.21 (PB14/URT3.RXD/SPI2.DAT2/TRGM0.P02/ADC0.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); also elsewhere on the board
/UART_DTR: U1.47 (PA06/TMR0.CAPT0/URT1.RXD/I2C1.SDA/SPI0.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); also elsewhere on the board
/UART_RTS: U1.46 (PA07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI0.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); also elsewhere on the board
/UART_RX: U1.3 (PA09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI3.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); also elsewhere on the board
/UART_TX: U1.2 (PA08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI3.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); also elsewhere on the board
/USB_D+: U1.44 (PA24/I2C2.SCL/SPI1.CS2/XPI0.CA_CS1/TRGM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); also elsewhere on the board
/USB_D-: U1.43 (PA25/I2C2.SDA/SPI1.CS1/XPI0.CA_DQS/TRGM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); also elsewhere on the board
/VREF: R9.1; also elsewhere on the board
/XIN: C21.1, U1.35 (XTALI), Y1.1
/XOUT: C22.1, U1.36 (XTALO), Y1.3
unnamed: R22.2, U1.40 (PA28/I2C3.SDA/SPI1.MISO/XPI0.CA_D0/TRGM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)
unnamed: R23.2, U1.39 (PA29/I2C3.SCL/SPI1.MOSI/XPI0.CA_D2/TRGM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)

Parts:
C55, C56: 10u; C_0603_1608Metric
C58: 100u; CP_EIA-3528-21_Kemet-B
J1: IDC 2x10p 夹板; Conn_02x10_IDC_SMD
J2: USB_C_Receptacle_USB2.0; USB-C-SMD_SHOU_TYPE-C-16P-CB1.6
Q1, Q3: AO3401A; SOT-23
Q2, Q4: 2N7002; SOT-323_SC-70
R14, R15: 5.1k; R_0402_1005Metric
R16: 4.7k; R_0402_1005Metric
R19, R20: 100k; R_0402_1005Metric
U14: MT9700; SOT-23-5
U15, U16, U17, U18: ESD0524P; DFN-10_L2.5-W1.0-P0.50-BL-A

Connections:
+5V: C55.2, C58.1, Q1.2 (S), R19.1, U14.1 (VOUT); also elsewhere on the board
+5V_OUT: J1.19, Q1.3 (D)
/Interface /<NO NET>: J1.5, U16.2, U16.9; also elsewhere on the board
/Interface /SRST: J1.15, U17.2, U17.9; also elsewhere on the board
/Interface /SWCLK/TCK: J1.9, U16.5, U16.6; also elsewhere on the board
/Interface /SWDIO/TMS: J1.7, U16.4, U16.7; also elsewhere on the board
/Interface /TDO: J1.13, U17.1, U17.10; also elsewhere on the board
/Interface /TRST: J1.3, U16.1, U16.10; also elsewhere on the board
/Interface /UART_DTR: J1.14, U18.1, U18.10; also elsewhere on the board
/Interface /UART_RTS: J1.16, U18.2, U18.9; also elsewhere on the board
/Interface /UART_RX: J1.20, U18.5, U18.6; also elsewhere on the board
/Interface /UART_TX: J1.18, U18.4, U18.7; also elsewhere on the board
/P_EN: Q2.1 (G), Q4.1 (G); also elsewhere on the board
/USB_D+: J2.A6 (D+), J2.B6 (D+), U15.5, U15.6; also elsewhere on the board
/USB_D-: J2.A7 (D-), J2.B7 (D-), U15.4, U15.7; also elsewhere on the board
/VREF: J1.1; also elsewhere on the board
unnamed: J2.A5 (CC1), R14.1
unnamed: J2.B5 (CC2), R15.1
unnamed: Q1.1 (G), Q2.3 (D), R19.2
unnamed: Q3.1 (G), Q4.3 (D), R20.2
unnamed: R16.2, U14.3 (SET)
TRANS_VCC_OUT: J1.2, Q3.3 (D)
VBUS: C56.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U14.4 (EN), U14.5 (VIN)

Parts:
C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C42, C43, C44, C45: 0.1u; C_0402_1005Metric
R13: 0R; R_0603_1608Metric
U2, U3, U4, U5, U6, U7, U8, U9, U11, U12: SN74LVC1T45DCK; SOT-363_SC-70-6

Connections:
+3V3: C24.2, C26.2, C28.2, C30.2, C32.2, C34.2, C36.2, C38.2, C42.2, C44.2, U2.1 (VCCA), U2.5 (DIR), U3.1 (VCCA), U4.1 (VCCA), U5.1 (VCCA), U5.5 (DIR), U6.1 (VCCA), U6.5 (DIR), U7.1 (VCCA), U7.5 (DIR), U8.1 (VCCA), U8.5 (DIR), U9.1 (VCCA), U11.1 (VCCA), U11.5 (DIR), U12.1 (VCCA), U12.5 (DIR); also elsewhere on the board
/Interface /<NO NET>: U5.4 (B); also elsewhere on the board
/Interface /SRST: U7.4 (B); also elsewhere on the board
/Interface /SWCLK/TCK: U2.4 (B); also elsewhere on the board
/Interface /SWDIO/TMS: U3.4 (B); also elsewhere on the board
/Interface /TDO: U4.4 (B); also elsewhere on the board
/Interface /TRST: U6.4 (B); also elsewhere on the board
/Interface /UART_DTR: U11.4 (B); also elsewhere on the board
/Interface /UART_RTS: U12.4 (B); also elsewhere on the board
/Interface /UART_RX: U9.4 (B); also elsewhere on the board
/Interface /UART_TX: U8.4 (B); also elsewhere on the board
/SRST: U7.3 (A); also elsewhere on the board
/SWCLK/TCK: U2.3 (A); also elsewhere on the board
/SWDIO_DIR: U3.5 (DIR); also elsewhere on the board
/SWDIO/TMS: U3.3 (A); also elsewhere on the board
/TDI: U5.3 (A); also elsewhere on the board
/TDO: U4.3 (A); also elsewhere on the board
/TRST: U6.3 (A); also elsewhere on the board
/UART_DTR: U11.3 (A); also elsewhere on the board
/UART_RTS: U12.3 (A); also elsewhere on the board
/UART_RX: U9.3 (A); also elsewhere on the board
/UART_TX: U8.3 (A); also elsewhere on the board
VEE: C25.1, C27.1, C29.1, C31.1, C33.1, C35.1, C37.1, C39.1, C43.1, C45.1, R13.2, U2.6 (VCCB), U3.6 (VCCB), U4.6 (VCCB), U5.6 (VCCB), U6.6 (VCCB), U7.6 (VCCB), U8.6 (VCCB), U9.6 (VCCB), U11.6 (VCCB), U12.6 (VCCB)

Parts:
C1, C3, C5, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C53: 0.1u; C_0402_1005Metric
C2, C6: 4.7u; C_0402_1005Metric
C4, C9, C48: 10u; C_0402_1005Metric
C7, C8: 22u; C_0402_1005Metric
C40: 1u; C_0402_1005Metric
C41, C46, C47, C51: 10u; C_0603_1608Metric
C49, C50: 220p; C_0402_1005Metric
C52, C54: 1n; C_0402_1005Metric
L1: 4.7uH; L_1008_2520Metric
L2, L3: 1.5u; L_1008_2520Metric
R2: 22.1k; R_0402_1005Metric
R3, R4, R5: 100k; R_0402_1005Metric
R6: 15.8k; R_0402_1005Metric
R7: 88.7k; R_0402_1005Metric
R8: 150k; R_0402_1005Metric
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
U10: EA3036C; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U13: LMV321; SOT-353_SC-70-5

Connections:
+3V3: C4.1, C5.1, C11.1, C12.1, C13.1, C14.1, C15.1, C48.2, C49.2, L2.1, R3.2, U1.6 (VIO_B00), U1.16 (VPMC), U1.29 (VIO_B01), U1.31 (VREFH), U1.32 (VANA), U1.34 (VIO_B00); also elsewhere on the board
+5V: C40.1, C41.1, C46.1, C47.1, C53.1, U10.7 (VIN2), U10.8 (EN2), U10.9 (EN1), U10.10 (VIN1), U10.16 (VCC), U13.5 (V+); also elsewhere on the board
/Power/TRANS_FB: C50.2, R4.2, R5.1, R6.1, U10.3 (FB2)
/Power/TRANS_VREF: C52.2, R5.2, U13.3 (-), U13.4
/TRANS_PWM: R7.1; also elsewhere on the board
unnamed: C52.1, R7.2, R8.1
unnamed: L1.2, U1.15 (DCDC_LP)
unnamed: C3.1, C6.1, U1.10 (VDD_OTPCAP)
unnamed: C1.1, C2.1, U1.17 (VDD_PMCCAP)
unnamed: C49.1, R2.1, R3.1, U10.14 (FB1)
unnamed: L2.2, U10.11 (LX1)
unnamed: L3.2, U10.6 (LX2)
unnamed: C54.1, R8.2, U13.1 (+)
VDD_SOC: C7.1, C8.1, C9.1, C10.1, C16.1, C17.1, C18.1, C19.1, C20.1, L1.1, U1.5 (VDD_SOC), U1.9 (VDD_SOC), U1.28 (VDD_SOC), U1.33 (VDD_SOC), U1.45 (VDD_SOC)

Notes on the sheet:
TRANS_VREF的电压范围为0-3.3V 映射到TRANS_VCC上的电压为1.7-5V

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
Board: 4 copper layers, 26.0 x 35.0 mm, 112 parts (0 on the bottom side), 62 nets.

## Commit log

2024-07-11 init
2024-07-11 add: 添加原理图和PCB
2024-07-11 update: 更新gitignore
2024-07-11 update: readme
2024-07-19 update: 添加一些丝印
2024-07-28 update: 更新设计
2024-08-05 update: 1.1.0设计
2024-09-06 update: README.md
